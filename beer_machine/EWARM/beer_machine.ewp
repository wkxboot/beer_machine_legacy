# IAR project beer_machine.ewp, settings and files
configuration beer_machine (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Src/board; ../Src/led; ../Src/tm1629a; ../Src/tasks; ../Src/serial; ../Src/debug/log; ../Src/debug/log/SEGGER_RTT_V612j/RTT; ../Src/debug/log/SEGGER_RTT_V612j/Syscalls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: beer_machine.bin
  ILINK.IlinkOutputFile: beer_machine.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: adc.c dma.c freertos.c gpio.c i2c.c iwdg.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_it.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_dfu_if.c main.c gpio.c adc.c dma.c freertos.c i2c.c iwdg.c spi.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_dfu_if.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/board
    ../Src/board/: beer_machine.c
  group Application/User/debug/cpu
    ../Src/debug/CPU/: cpu_utils.c
  group Application/User/debug/log
    ../Src/debug/log/: log.c
  group Application/User/debug/log/segger_rtt
    ../Src/debug/log/SEGGER_RTT_V612j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Src/debug/log/SEGGER_RTT_V612j/Syscalls/: SEGGER_RTT_Syscalls_IAR.c
  group Application/User/debug/log/st_serial
    ../Src/debug/log/st_serial/: st_serial.c
  group Application/User/led
    ../Src/led/: led.c
  group Application/User/serial
    ../Src/serial/: serial.c
  group Application/User/tasks
    ../Src/tasks/: adc_task.c alarm_task.c compressor_task.c display_task.c pressure_task.c tasks_init.c temperature_task.c
  group Application/User/tm1629a
    ../Src/tm1629a/: tm1629a.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
    ..//Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s port.c portasm.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c usbd_dfu.c
